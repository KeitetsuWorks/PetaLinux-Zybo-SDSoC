SRC_URI += "file://user_2018-08-13-23-56-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

